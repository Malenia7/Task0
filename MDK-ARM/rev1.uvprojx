# Keil uVision project rev1.uvprojx, settings and files
target rev1 (6160000::V6.16::ARMCLANG)
  device: STM32U575RITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: rev1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx
  c include: ../Core/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../Drivers/CMSIS/Include;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include;../Drivers/efsm
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c gpdma.c i2c.c icache.c memorymap.c octospi.c rtc.c spi.c tim.c usart.c stm32u5xx_it.c stm32u5xx_hal_msp.c bsp_ch579_uart2.c bsp_ili9341_spi.c bsp_mpu6050_i2c.c
    ./: api_user.c
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXDMA.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp OSWrappers.cpp
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_ospi.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Drivers/efsm
    ../Drivers/efsm/: efsm.c efsm_hal.c
  group Drivers/Motion_Driver
    ../Drivers/Motion_Driver/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Drivers/Max30102_Maxim
    ../Drivers/MAX30102_Maxim/: algorithm.c max30102.c
  group gui
    ../touchgfx/gui/src/apppage_screen/: apppagepresenter.cpp apppageview.cpp
    ../touchgfx/gui/src/dialpage_screen/: dialpagepresenter.cpp dialpageview.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/containers/: menuelement.cpp
    ../touchgfx/gui/src/model/: model.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_notosanssc_vf_16_4bpp_0.cpp font_notosanssc_vf_20_4bpp_0.cpp font_notosanssc_vf_20_4bpp_10.cpp font_notosanssc_vf_20_4bpp_11.cpp font_notosanssc_vf_20_4bpp_12.cpp font_notosanssc_vf_20_4bpp_9.cpp font_notosanssc_vf_26_4bpp_0.cpp font_notosanssc_vf_26_4bpp_10.cpp font_notosanssc_vf_26_4bpp_11.cpp font_notosanssc_vf_26_4bpp_12.cpp font_notosanssc_vf_26_4bpp_13.cpp font_notosanssc_vf_26_4bpp_14.cpp font_notosanssc_vf_26_4bpp_16.cpp font_notosanssc_vf_26_4bpp_17.cpp font_notosanssc_vf_26_4bpp_18.cpp font_notosanssc_vf_26_4bpp_9.cpp font_timesbi_13_4bpp_0.cpp font_timesbi_20_4bpp_0.cpp font_timesbi_40_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_notosanssc_vf_16_4bpp.cpp kerning_notosanssc_vf_20_4bpp.cpp kerning_notosanssc_vf_26_4bpp.cpp kerning_timesbi_13_4bpp.cpp kerning_timesbi_20_4bpp.cpp kerning_timesbi_40_4bpp.cpp table_notosanssc_vf_16_4bpp.cpp table_notosanssc_vf_20_4bpp.cpp table_notosanssc_vf_26_4bpp.cpp table_timesbi_13_4bpp.cpp table_timesbi_20_4bpp.cpp table_timesbi_40_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/gui_generated/src/apppage_screen/: apppageviewbase.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/dialpage_screen/: dialpageviewbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/container/: image_alipay-60x60.cpp image_alipay_pressed-60x60.cpp image_backlight_off-50x50.cpp image_backlight_on-50x50.cpp image_beep_50x50.cpp image_beep_pressed_50x50.cpp image_breathe-60x60.cpp image_breathe_pressed-60x60.cpp image_chip.cpp image_count-60x60.cpp image_count_pressed-60x60.cpp image_dc_fan_50x50.cpp image_dc_fan__pressed_50x50.cpp image_heartrate_start_51x47.cpp image_humidity_22x28.cpp image_light_29x29.cpp image_lpbam_off-50x50.cpp image_lpbam_on-50x50.cpp image_message_50x50.cpp image_message_no-50x50.cpp image_mute_off-50x50.cpp image_mute_on-50x50.cpp image_overlay-240x240.cpp image_stm32u5_tb.cpp image_stress-60x60.cpp image_stress_pressed-60x60.cpp image_temperature_15x32.cpp image_tool.cpp image_vibrate_50x50.cpp image_vibrate_pressed_50x50.cpp image_water_off-50x50.cpp image_water_on-50x50.cpp image_wifi_rssi_1_signal.cpp image_wifi_rssi_2_signal.cpp image_wifi_rssi_3_signal.cpp image_wifi_rssi_4_signal.cpp image_wifi_rssi_no_signal.cpp image_wifilink-38x38.cpp image_wifilink-38x38_pressed.cpp image_wifilink_pressed-37x26.cpp
    ../touchgfx/generated/images/src/__generated/: image_alternate_theme_images_widgets_slider_horizontal_thin_rounded_dark.cpp image_alternate_theme_images_widgets_slider_vertical_thick_filler_small.cpp image_alternate_theme_images_widgets_swipecontainer_medium_off_normal.cpp image_alternate_theme_images_widgets_swipecontainer_medium_on_active.cpp
    ../touchgfx/generated/images/src/apppage/: image_applicationpage_image_6050.cpp image_applicationpage_image_battery.cpp image_applicationpage_image_buzzer.cpp image_applicationpage_image_chipinfo.cpp image_applicationpage_image_health.cpp image_applicationpage_image_motor.cpp image_applicationpage_image_pressed_6050.cpp image_applicationpage_image_pressed_battery.cpp image_applicationpage_image_pressed_buzzer.cpp image_applicationpage_image_pressed_chip.cpp image_applicationpage_image_pressed_health.cpp image_applicationpage_image_pressed_motor.cpp image_applicationpage_image_pressed_temp.cpp image_applicationpage_image_pressed_wifi.cpp image_applicationpage_image_temp.cpp image_applicationpage_image_wifi.cpp
    ../touchgfx/generated/images/src/dialpage/: image_watchface_analog.cpp image_watchface_digital_circle.cpp image_watchhand_hour.cpp image_watchhand_minute.cpp image_watchhand_second.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/containers/: menuelementbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m33/Keil6.x/: touchgfx_core_wchar16.lib
software components: CMSIS:CORE 4.3.0
